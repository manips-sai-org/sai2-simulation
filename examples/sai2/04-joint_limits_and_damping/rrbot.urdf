Commit message: tmp state

File: examples/sai2/04-joint_limits_and_damping/rrbot.urdf (robot description, URDF)
Before this commit: robot RRBot_description, 3 links, 2 joints
Joints:
- joint j1: type revolute -> continuous
